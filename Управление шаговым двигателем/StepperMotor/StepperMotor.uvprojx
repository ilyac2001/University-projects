# Keil uVision project StepperMotor.uvprojx, settings and files
target STM32F072C8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F072C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SettingPult +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Code
    ./: main.c timer.c timer.h motor.c motor.h led.c led.h btn.c btn.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
